#include "Fb2Encoding.h"

#include <algorithm>
#include <cctype>
#include <string>

namespace Fb2Encoding {
namespace {

std::string normalizeName(const char* name) {
  std::string result = name ? name : "";
  std::transform(result.begin(), result.end(), result.begin(),
                 [](unsigned char c) { return static_cast<char>(std::tolower(c)); });
  result.erase(std::remove_if(result.begin(), result.end(), [](char c) { return c == '_' || c == ' '; }), result.end());
  return result;
}

constexpr int WINDOWS_1251_HIGH[128] = {
    0x0402, 0x0403, 0x201A, 0x0453, 0x201E, 0x2026, 0x2020, 0x2021, 0x20AC, 0x2030, 0x0409, 0x2039, 0x040A,
    0x040C, 0x040B, 0x040F, 0x0452, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, -1,     0x2122,
    0x0459, 0x203A, 0x045A, 0x045C, 0x045B, 0x045F, 0x00A0, 0x040E, 0x045E, 0x0408, 0x00A4, 0x0490, 0x00A6,
    0x00A7, 0x0401, 0x00A9, 0x0404, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x0407, 0x00B0, 0x00B1, 0x0406, 0x0456,
    0x0491, 0x00B5, 0x00B6, 0x00B7, 0x0451, 0x2116, 0x0454, 0x00BB, 0x0458, 0x0405, 0x0455, 0x0457, 0x0410,
    0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D,
    0x041E, 0x041F, 0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427, 0x0428, 0x0429, 0x042A,
    0x042B, 0x042C, 0x042D, 0x042E, 0x042F, 0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437,
    0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F, 0x0440, 0x0441, 0x0442, 0x0443, 0x0444,
    0x0445, 0x0446, 0x0447, 0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F,
};

constexpr int KOI8_R_HIGH[128] = {
    0x2500, 0x2502, 0x250C, 0x2510, 0x2514, 0x2518, 0x251C, 0x2524, 0x252C, 0x2534, 0x253C, 0x2580, 0x2584,
    0x2588, 0x258C, 0x2590, 0x2591, 0x2592, 0x2593, 0x2320, 0x25A0, 0x2219, 0x221A, 0x2248, 0x2264, 0x2265,
    0x00A0, 0x2321, 0x00B0, 0x00B2, 0x00B7, 0x00F7, 0x2550, 0x2551, 0x2552, 0x0451, 0x2553, 0x2554, 0x2555,
    0x2556, 0x2557, 0x2558, 0x2559, 0x255A, 0x255B, 0x255C, 0x255D, 0x255E, 0x255F, 0x2560, 0x2561, 0x0401,
    0x2562, 0x2563, 0x2564, 0x2565, 0x2566, 0x2567, 0x2568, 0x2569, 0x256A, 0x256B, 0x256C, 0x00A9, 0x044E,
    0x0430, 0x0431, 0x0446, 0x0434, 0x0435, 0x0444, 0x0433, 0x0445, 0x0438, 0x0439, 0x043A, 0x043B, 0x043C,
    0x043D, 0x043E, 0x043F, 0x044F, 0x0440, 0x0441, 0x0442, 0x0443, 0x0436, 0x0432, 0x044C, 0x044B, 0x0437,
    0x0448, 0x044D, 0x0449, 0x0447, 0x044A, 0x042E, 0x0410, 0x0411, 0x0426, 0x0414, 0x0415, 0x0424, 0x0413,
    0x0425, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E, 0x041F, 0x042F, 0x0420, 0x0421, 0x0422,
    0x0423, 0x0416, 0x0412, 0x042C, 0x042B, 0x0417, 0x0428, 0x042D, 0x0429, 0x0427, 0x042A,
};

constexpr int WINDOWS_1252_HIGH[128] = {
    0x20AC, -1,     0x201A, 0x0192, 0x201E, 0x2026, 0x2020, 0x2021, 0x02C6, 0x2030, 0x0160, 0x2039, 0x0152,
    -1,     0x017D, -1,     -1,     0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, 0x02DC, 0x2122,
    0x0161, 0x203A, 0x0153, -1,     0x017E, 0x0178, 0x00A0, 0x00A1, 0x00A2, 0x00A3, 0x00A4, 0x00A5, 0x00A6,
    0x00A7, 0x00A8, 0x00A9, 0x00AA, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x00AF, 0x00B0, 0x00B1, 0x00B2, 0x00B3,
    0x00B4, 0x00B5, 0x00B6, 0x00B7, 0x00B8, 0x00B9, 0x00BA, 0x00BB, 0x00BC, 0x00BD, 0x00BE, 0x00BF, 0x00C0,
    0x00C1, 0x00C2, 0x00C3, 0x00C4, 0x00C5, 0x00C6, 0x00C7, 0x00C8, 0x00C9, 0x00CA, 0x00CB, 0x00CC, 0x00CD,
    0x00CE, 0x00CF, 0x00D0, 0x00D1, 0x00D2, 0x00D3, 0x00D4, 0x00D5, 0x00D6, 0x00D7, 0x00D8, 0x00D9, 0x00DA,
    0x00DB, 0x00DC, 0x00DD, 0x00DE, 0x00DF, 0x00E0, 0x00E1, 0x00E2, 0x00E3, 0x00E4, 0x00E5, 0x00E6, 0x00E7,
    0x00E8, 0x00E9, 0x00EA, 0x00EB, 0x00EC, 0x00ED, 0x00EE, 0x00EF, 0x00F0, 0x00F1, 0x00F2, 0x00F3, 0x00F4,
    0x00F5, 0x00F6, 0x00F7, 0x00F8, 0x00F9, 0x00FA, 0x00FB, 0x00FC, 0x00FD, 0x00FE, 0x00FF,
};

constexpr int ISO_8859_5_HIGH[128] = {
    0x0080, 0x0081, 0x0082, 0x0083, 0x0084, 0x0085, 0x0086, 0x0087, 0x0088, 0x0089, 0x008A, 0x008B, 0x008C,
    0x008D, 0x008E, 0x008F, 0x0090, 0x0091, 0x0092, 0x0093, 0x0094, 0x0095, 0x0096, 0x0097, 0x0098, 0x0099,
    0x009A, 0x009B, 0x009C, 0x009D, 0x009E, 0x009F, 0x00A0, 0x0401, 0x0402, 0x0403, 0x0404, 0x0405, 0x0406,
    0x0407, 0x0408, 0x0409, 0x040A, 0x040B, 0x040C, 0x00AD, 0x040E, 0x040F, 0x0410, 0x0411, 0x0412, 0x0413,
    0x0414, 0x0415, 0x0416, 0x0417, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E, 0x041F, 0x0420,
    0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427, 0x0428, 0x0429, 0x042A, 0x042B, 0x042C, 0x042D,
    0x042E, 0x042F, 0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437, 0x0438, 0x0439, 0x043A,
    0x043B, 0x043C, 0x043D, 0x043E, 0x043F, 0x0440, 0x0441, 0x0442, 0x0443, 0x0444, 0x0445, 0x0446, 0x0447,
    0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F, 0x2116, 0x0451, 0x0452, 0x0453, 0x0454,
    0x0455, 0x0456, 0x0457, 0x0458, 0x0459, 0x045A, 0x045B, 0x045C, 0x00A7, 0x045E, 0x045F,
};

constexpr int CP866_HIGH[128] = {
    0x0410, 0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C,
    0x041D, 0x041E, 0x041F, 0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427, 0x0428, 0x0429,
    0x042A, 0x042B, 0x042C, 0x042D, 0x042E, 0x042F, 0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436,
    0x0437, 0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F, 0x2591, 0x2592, 0x2593, 0x2502,
    0x2524, 0x2561, 0x2562, 0x2556, 0x2555, 0x2563, 0x2551, 0x2557, 0x255D, 0x255C, 0x255B, 0x2510, 0x2514,
    0x2534, 0x252C, 0x251C, 0x2500, 0x253C, 0x255E, 0x255F, 0x255A, 0x2554, 0x2569, 0x2566, 0x2560, 0x2550,
    0x256C, 0x2567, 0x2568, 0x2564, 0x2565, 0x2559, 0x2558, 0x2552, 0x2553, 0x256B, 0x256A, 0x2518, 0x250C,
    0x2588, 0x2584, 0x258C, 0x2590, 0x2580, 0x0440, 0x0441, 0x0442, 0x0443, 0x0444, 0x0445, 0x0446, 0x0447,
    0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F, 0x0401, 0x0451, 0x0404, 0x0454, 0x0407,
    0x0457, 0x040E, 0x045E, 0x00B0, 0x2219, 0x00B7, 0x221A, 0x2116, 0x00A4, 0x25A0, 0x00A0,
};
}  // namespace

namespace {
// Resolve an encoding label to its high-byte table, or nullptr when the encoding
// is not a supported single-byte one.
const int* highTableFor(const std::string& name) {
  if (name == "windows-1251" || name == "cp1251" || name == "windows1251") return WINDOWS_1251_HIGH;
  if (name == "koi8-r" || name == "koi8r") return KOI8_R_HIGH;
  if (name == "windows-1252" || name == "cp1252" || name == "windows1252") return WINDOWS_1252_HIGH;
  // Latin-1 is CP1252 minus the 0x80-0x9F block. Mapping it through the CP1252
  // table is deliberate: real-world files labelled ISO-8859-1 routinely use the
  // CP1252 punctuation in that range, and rejecting those bytes would show the
  // replacement glyph instead of the intended quote or dash.
  if (name == "iso-8859-1" || name == "iso88591" || name == "latin1" || name == "l1") return WINDOWS_1252_HIGH;
  if (name == "iso-8859-5" || name == "iso88595") return ISO_8859_5_HIGH;
  if (name == "cp866" || name == "ibm866" || name == "dos-866") return CP866_HIGH;
  return nullptr;
}
}  // namespace

int decodeByte(const char* encodingName, uint8_t value) {
  if (value < 0x80) {
    return value;
  }

  const int* table = highTableFor(normalizeName(encodingName));
  return table ? table[value - 0x80] : -1;
}

bool isSupported(const char* encodingName) { return highTableFor(normalizeName(encodingName)) != nullptr; }

void appendUtf8(std::string& out, int codepoint) {
  if (codepoint < 0) codepoint = 0xFFFD;
  if (codepoint < 0x80) {
    out.push_back(static_cast<char>(codepoint));
  } else if (codepoint < 0x800) {
    out.push_back(static_cast<char>(0xC0 | (codepoint >> 6)));
    out.push_back(static_cast<char>(0x80 | (codepoint & 0x3F)));
  } else {
    out.push_back(static_cast<char>(0xE0 | (codepoint >> 12)));
    out.push_back(static_cast<char>(0x80 | ((codepoint >> 6) & 0x3F)));
    out.push_back(static_cast<char>(0x80 | (codepoint & 0x3F)));
  }
}

std::string toUtf8(const char* encodingName, const char* bytes, size_t length) {
  std::string out;
  if (!bytes) return out;
  const int* table = highTableFor(normalizeName(encodingName));
  if (!table) {
    return std::string(bytes, length);
  }
  // Each source byte is exactly one codepoint, so callers can convert a position
  // in the result back to a source offset by counting codepoints.
  out.reserve(length + length / 2);
  for (size_t i = 0; i < length; i++) {
    const auto value = static_cast<uint8_t>(bytes[i]);
    appendUtf8(out, value < 0x80 ? value : table[value - 0x80]);
  }
  return out;
}

size_t bomLength(const char* sample, const size_t length) {
  if (!sample || length < 3) return 0;
  const auto* bytes = reinterpret_cast<const uint8_t*>(sample);
  return (bytes[0] == 0xEF && bytes[1] == 0xBB && bytes[2] == 0xBF) ? 3 : 0;
}

const char* detect(const char* sample, const size_t length) {
  if (!sample || length == 0) return UTF8;
  if (bomLength(sample, length) > 0) return UTF8;

  const auto* bytes = reinterpret_cast<const uint8_t*>(sample);

  // Pass 1: is the sample valid UTF-8? A truncated sequence at the very end is
  // expected (the sample cuts mid-character) and does not disqualify it.
  bool validUtf8 = true;
  size_t highByteCount = 0;
  for (size_t i = 0; i < length;) {
    const uint8_t b = bytes[i];
    if (b < 0x80) {
      i++;
      continue;
    }
    highByteCount++;
    size_t continuationBytes = 0;
    if ((b & 0xE0) == 0xC0) {
      continuationBytes = 1;
    } else if ((b & 0xF0) == 0xE0) {
      continuationBytes = 2;
    } else if ((b & 0xF8) == 0xF0) {
      continuationBytes = 3;
    } else {
      validUtf8 = false;
      break;
    }
    if (i + continuationBytes >= length) break;  // truncated tail, not a defect
    for (size_t k = 1; k <= continuationBytes; k++) {
      if ((bytes[i + k] & 0xC0) != 0x80) {
        validUtf8 = false;
        break;
      }
    }
    if (!validUtf8) break;
    i += continuationBytes + 1;
  }

  // Pure ASCII is valid UTF-8 and needs no transcoding either way.
  if (validUtf8 || highByteCount == 0) return UTF8;

  // Pass 2: Cyrillic or Western? Not by byte range — Western accented lowercase
  // in CP1252 (à, é, ç, ù) sits at 0xE0+, exactly where CP1251 keeps Cyrillic
  // lowercase. What separates them is density: in Cyrillic text nearly every
  // letter is a high byte, while in Western text high bytes are occasional
  // accents among ASCII letters.
  // Counted over the whole sample here, not reused from pass 1: that loop stops
  // at the first invalid sequence, which for single-byte text is the very first
  // high byte.
  size_t lowerHalf = 0;  // 0xC0-0xDF
  size_t upperHalf = 0;  // 0xE0-0xFF
  size_t highBytes = 0;
  size_t letterCount = 0;
  for (size_t i = 0; i < length; i++) {
    const uint8_t b = bytes[i];
    if (b >= 0x80) {
      highBytes++;
      letterCount++;
      if (b <= 0xDF) {
        if (b >= 0xC0) lowerHalf++;
      } else {
        upperHalf++;
      }
      continue;
    }
    if ((b >= 'A' && b <= 'Z') || (b >= 'a' && b <= 'z')) letterCount++;
  }

  constexpr size_t CYRILLIC_HIGH_BYTE_PERCENT = 40;
  if (letterCount == 0 || highBytes * 100 / letterCount < CYRILLIC_HIGH_BYTE_PERCENT) {
    return WINDOWS_1252;
  }

  // Cyrillic it is. The two common encodings put lowercase in opposite halves of
  // the high range — CP1251 has uppercase at 0xC0-0xDF and lowercase at 0xE0-0xFF,
  // KOI8-R the reverse — and prose is overwhelmingly lowercase, so comparing the
  // two counts separates them on any run of real text.
  return upperHalf >= lowerHalf ? WINDOWS_1251 : KOI8_R;
}

}  // namespace Fb2Encoding
